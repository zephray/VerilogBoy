# Repository zephray/VerilogBoy

File README.md (part):

VerilogBoy
==========

Coding for fun - the hard way. Trying to implement a Game Boy® compatible machine with Verilog.

This project is an open source Game Boy® compatible console Verilog RTL implementation.

# System Architecture

The main system architecture is designed as follows (outdated):

There are three major parts needs to be implemented: the Game Boy CPU (8-bit CISC Processor called SM83, Intel 8080 like), the PPU (Pixel Processing Unit), and the sound unit (sometimes referred as a PSG, Programmable Sound Generator). Several interfacing modules are needed to support the IO capability provided by the hardware (such as an FPGA development board).

# Targets (Ports)

Current Pano Logic G1 is the only supported platform.

# Progress

Refactoring in progress. Current version could run several commerical games with no noticable glitch on the Pano Logic G1 device. 'Master' branch contains the previous version that runs on the ML505.

 - [x] SM83 CPU (Refactoring stage 1 done, passes all Blargg's tests)
 - [x] PPU (Pixel Processing Unit, Pixel-FIFO architecture)
 - [x] OAMDMA (Object Attribute Memory DMA)
 - [x] PSG (Programmable Sound Generator)
 - [x] Timer
 - [x] Link (Dummy link module, allows some games to run in single player mode)

Next step would be improving the accuracy.

Photo of VerilogBoy on Pano G1 running open source GameBoy game [Tobu Tobu Girl](http://tangramgames.dk/tobutobugirl/):

For progress regarding different ports, view README.md under the specific target folder.

# Accuracy

This project is not built to be entirely accurate, but built with accuracy in mind. Most of the CPU timing should follow the original DMG-CPU, and implement a rudimentary 2-stage pipelining just as the original one does. 

Here are the results of several tests I have tried to run on it.

PPU implementation is ... wrong: There are two pipelines in the GameBoy PPU, one for BG and one for sprite. I only implemented one for both. There is only one fetcher, though.

Note: Tests which depends on the revision / model of GameBoy are omitted. VerilogBoy only focus on behaviors that are common among all monochrome GameBoys (GS).

## Blargg's tests

| Test              | mooneye-gb | BGB  | Gambatte | Higan | MESS | VerilogBoy |
| ----------------- | ---------- | ---- | -------- | ----- | ---- |------------|
| cpu instrs        | :+1:       | :+1: | :+1:     | :+1:  | :+1: | :+1:       |

Notes: other tests hasn't been tried.

## Mooneye GB acceptance tests

| Test                    | mooneye-gb | BGB  | Gambatte | Higan  | MESS | VerilogBoy |
| ----------------------- | ---------- | ---- | -------- | ------ | ---- |------------|
| add sp e timing         | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| call timing             | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| call timing2            | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| call cc_timing          | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| call cc_timing2         | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| di timing GS            | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| div timing              | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| ei sequence             | :+1:       | :+1: | :+1:     | :+1:   | :x:  | :+1:       |
| ei timing               | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| halt ime0 ei            | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| halt ime0 nointr_timing | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| halt ime1 timing        | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| halt ime1 timing2 GS    | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| if ie registers         | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| intr timing             | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| jp timing               | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| jp cc timing            | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| ld hl sp e timing       | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| oam dma_restart         | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| oam dma start           | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| oam dma timing          | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| pop timing              | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| push timing             | :+1:       | :x:  | :x:      | :+1:   | :+1: | :+1:       |
| rapid di ei             | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| ret timing              | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| ret cc timing           | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| reti timing             | :+1:       | :x:  | :+1:     | :+1:   | :+1: | :+1:       |
| reti intr timing        | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| rst timing              | :+1:       | :x:  | :x:      | :+1:   | :+1: | :+1:       |

### Instructions

| Test                        | mooneye-gb | BGB  | Gambatte | Higan  | MESS | VerilogBoy |
| --------------------------- | ---------- | ---- | -------- | ------ | ---- |------------|
| daa                         | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |

### Interrupt handling

| Test                        | mooneye-gb | BGB  | Gambatte | Higan  | MESS | VerilogBoy |
| --------------------------- | ---------- | ---- | -------- | ------ | ---- |------------|
| ie push                     | :+1:       | :x:  | :x:      | :x:    | :x:  | :+1:       |

### OAM DMA

| Test                        | mooneye-gb | BGB  | Gambatte | Higan  | MESS | VerilogBoy |
| --------------------------- | ---------- | ---- | -------- | ------ | ---- |------------|
| basic                       | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| reg_read                    | :+1:       | :+1: | :+1:     | :x:    | :x:  | :+1:       |
| sources dmgABCmgbS          | :+1:       | :+1: | :x:      | :x:    | :x:  | :x:        |

### Serial

| Test                        | mooneye-gb | BGB  | Gambatte | Higan | MESS | VerilogBoy |
| --------------------------- | ---------- | ---- | -------- | ------| ---- |------------|
| boot sclk align dmgABCmgb   | :x:        | :+1: | :+1:     | :x:   | :x:  | :x:        |

Note: this test only seems to test the time to finish the first transfer. What about the second? (Delta time required to do a transfer and get notified by the interrupt)

### PPU

| Test                        | mooneye-gb | BGB  | Gambatte | Higan | MESS | VerilogBoy |
| --------------------------- | ---------- | ---- | -------- | ------| ---- |------------|
| hblank ly scx timing GS     | :+1:       | :+1: | :x:      | :x:   | :+1: | :x:        |
| intr 1 2 timing GS          | :+1:       | :+1: | :+1:     | :+1:  | :+1: | :x:        |
| intr 2 0 timing             | :+1:       | :+1: | :x:      | :+1:  | :+1: | :x:        |
| intr 2 mode0 timing         | :+1:       | :+1: | :x:      | :x:   | :+1: | :x:        |
| intr 2 mode3 timing         | :+1:       | :+1: | :x:      | :x:   | :+1: | :x:        |
| intr 2 oam ok timing        | :+1:       | :+1: | :x:      | :x:   | :+1: | :x:        |
| intr 2 mode0 timing sprites | :x:        | :+1: | :x:      | :x:   | :+1: | :x:        |
| lcdon timing dmgABCmgbS     | :x:        | :+1: | :x:      | :x:   | :x:  | :x:        |
| lcdon write timing GS       | :x:        | :+1: | :x:      | :x:   | :x:  | :x:        |
| stat irq blocking           | :x:        | :+1: | :+1:     | :x:   | :+1: | :x:        |
| stat lyc onoff              | :x:        | :+1: | :x:      | :x:   | :x:  | :x:        |
| vblank stat intr GS         | :+1:       | :+1: | :x:      | :+1:  | :+1: | :x:        |

### Timer

| Test                 | mooneye-gb | BGB  | Gambatte | Higan  | MESS | VerilogBoy |
| -------------------- | ---------- | ---- | -------- | ------ | ---- |------------|
| div write            | :+1:       | :+1: | :x:      | :+1:   | :+1: | :+1:       |
| rapid toggle         | :+1:       | :+1: | :x:      | :x:    | :+1: | :+1:       |
| tim00 div trigger    | :+1:       | :+1: | :+1:     | :x:    | :+1: | :+1:       |
| tim00                | :+1:       | :+1: | :x:      | :+1:   | :+1: | :+1:       |
| tim01 div trigger    | :+1:       | :+1: | :x:      | :x:    | :+1: | :+1:       |
| tim01                | :+1:       | :+1: | :+1:     | :+1:   | :+1: | :+1:       |
| tim10 div trigger    | :+1:       | :+1: | :x:      | :x:    | :+1: | :+1:       |
| tim10                | :+1:       | :+1: | :x:      | :+1:   | :+1: | :+1:       |
| tim11 div trigger    | :+1:       | :+1: | :x:      | :x:    | :+1: | :+1:       |
| tim11                | :+1:       | :+1: | :x:      | :+1:   | :+1: | :+1:       |
| tima reload          | :+1:       | :+1: | :x:      | :x:    | :+1: | :+1:       |
| tima write reloading | :+1:       | :+1: | :x:      | :x:    | :+1: | :+1:       |
| tma write reloading  | :+1:       | :+1: | :x:      | :x:    | :+1: | :+1:       |

# Directory Structure

Note: things that will be removed in the near future may not shown here. Not all source files are shown here.

```
.
├── doc                          -- Documents
│   ├── control_unit.ods           -- CPU control unit LUT
│   ├── cpu_internal.md            -- CPU internal signal encoding
│   └── cpu.md                     -- CPU design note
├── LICENSE                      -- OHDL
├── Makefile                     -- Toplevel Makefile
├── README.md                    -- This document
├── roms                         -- Place for platform independent ROMs
│   ├── bootrom.s                  -- Boot ROM
│   ├── Makefile                   -- Makefile for building the Boot ROM
│   └── tests                      -- Unit tests
│       ├── compare.sh               -- Script for comparing results between VBC and emulator
│       ├── dmg_emu.exe              -- Reference emulator
│       └── Makefile                 -- Makefile for running tests
├── rtl                          -- RTL files
│   ├── alu.v                      -- ALU
│   ├── boy.v                      -- VerilogBoy portable top level file
│   ├── brom.v                     -- Boot ROM
│   ├── common.v                   -- Common definitions
│   ├── control.v                  -- Control Unit
│   ├── cpu.v                      -- CPU top level
│   ├── dma.v                      -- OAM DMA
│   ├── Makefile                   -- Makefile for building the VBC using Verilator
│   ├── mbc5.v                     -- Cartridge paging, optional
│   ├── ppu.v                      -- Pixel Processing Unit
│   ├── regfile.v                  -- CPU Register file
│   ├── singleport_ram.v           -- Singleport RAM template
│   ├── singlereg.v                -- Singlebit register template
│   └── timer.v                    -- Timer
├── sim                          -- Simualtion
│   └── verilator                  -- Verilator-based simulator 
│       ├── dispsim.cpp              -- LCD simulator based on SDL 2.0
│       ├── Makefile                 -- Makefile for building the simulator
│       ├── mbcsim.cpp               -- MBC cartridge controller simulator
│       ├── memsim.cpp               -- Boot ROM or Game ROM simulator
│       ├── mmrprobe.cpp             -- Unit for dumping memory or MMR accesses
│       └── vb_sim.cpp               -- Simulator main file
├── target                       -- Targets (ports) of VBC
│   ├── panog1                     -- Pano Logic G1 devices
│   │   ├── fpga                     -- FPGA RTL
│   │   │   ├── dualport_ram.v         -- Template of dual port RAM
│   │   │   ├── idt_clkgen.v           -- Code for interfacing with clock generator
│   │   │   ├── mig                    -- LPDDR memory controller
│   │   │   ├── mig_picorv_bridge.v    -- Bridge for connecting PicoRV32 and LPDDR controller
│   │   │   ├── mig.ucf                -- Timing constraint for memory controller
│   │   │   ├── mobile_ddr.v           -- Simulation model for LPDDR
│   │   │   ├── panog1.xise            -- ISE project file
│   │   │   ├── pano_top.v             -- Top level HDL
│   │   │   ├── pano.ucf               -- Main pin location constraint
│   │   │   ├── picorv32.v             -- PicoRV32 RISC-V softcore
│   │   │   ├── picosoc_mem.v          -- PicoRV32 scratchpad memory
│   │   │   ├── simple_uart.v          -- Simple UART transmitter 
│   │   │   ├── testbench.v            -- Testbench with LPDDR model
│   │   │   ├── usb_picorv_bridge.v    -- Bridge for connecting PicoRV32 and USB controller
│   │   │   ├── vga_font.v             -- VGA font ROM
│   │   │   ├── vga_mixer.v            -- Mixing PicoRV32 and VerilogBoy image
│   │   │   └── vga_timing.v           -- VGA timing generator
│   │   ├── fw                       -- Firmware for RV softcore
│   │   │   ├── bootloader             -- Bootloader for loading firmware from SPI Flash
│   │   │   │   ├── bootloader.c         -- Main source code
│   │   │   │   ├── Makefile             -- Makefile for building the bootloader
│   │   │   │   ├── sections_bl.lds      -- Link script
│   │   │   │   └── start_bl.s           -- Startup code
│   │   │   ├── dhrystone              -- Dhrystone test for RV softcore
│   │   │   ├── firmware               -- Firmware for softcore
│   │   │   │   ├── COPYING              -- GPLv2 License for firmware
│   │   │   │   ├── firmware.c           -- Main source code 
│   │   │   │   ├── isp1760.c            -- ISP1760 HCD
│   │   │   │   ├── isp_roothub.h        -- RootHub emulation for HCD (optional)
│   │   │   │   ├── Makefile             -- Makefile for building the firmware
│   │   │   │   ├── misc.c               -- Delay and other common routines
│   │   │   │   ├── sections.lds         -- Link script
│   │   │   │   ├── syscalls.c           -- Syscalls for the newlib
│   │   │   │   ├── term.c               -- Simple virtual terminal
│   │   │   │   ├── usb.c                -- Host USB stack
│   │   │   │   ├── usb_gamepad.c        -- Generic USB HIB gamepad driver
│   │   │   │   └── usb_storage.c        -- USB mass storage driver
│   │   │   └── README.md              -- README about firmware
│   │   └── README.md                -- README about Pano Logic G1 port
│   └── vbh                        -- VerilogBoy Handheld
│       ├── fpga                     -- FPGA RTL
│       └── fw                       -- Firmware for on-board MCU
└── tools                        -- Tools for building things
    ├── bin2mif                    -- Convert binary blob to mif
    └── vga_timing.xlsx            -- Tool for calculating VGA timing
```

# How to use

## Verilator-based simulator

Tested environment: Ubuntu 20.04 LTS, mac OS Big Sur. 

Dependencies: build-essential, verilator, libsdl2-dev, wine(optional, for unit test only, for now), rgbds(not available from apt, need build manually).

On Debian/ Ubuntu, do the following:

```
sudo apt install build-essential verilator libsdl2-dev wine byacc flex pkg-config libpng-dev
```

On macOS, do the following:

```
brew install verilator sdl2 pkg-config libpng
```

To install rgbds:

```
git clone https://github.com/rednex/rgbds
cd rgbds
make
make install
```

### Build

At project directory:
```
make
```

Copy the bootrom.mif to where it is required. (For example, target/panog1)

### Running unit-tests

At project directory:
```
cd roms/tests
make
./compare.sh
```

### Running ROMs

At project directory:
```
./sim/verilator/vb_sim <path_to_your_rom.gb> --mbc --nostop
```

Few parameters:
```
--nostop: Don't stop execution at halt/stop (but stop at illegal instructions)
--trace: Generate vcd waveform trace
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
## KiCad design hardware/pcb/pcb.kicad_pcb

File hardware/README.md:

Hardware
========

Please be aware all the information here is subject to change!

# Specification

* FPGA: Xilinx Spartan-7 XC7S25
* RAM: Micron MT41K64M16TW DDR3L-800 1Gb
* PMU: X-Powers AXP221
* EC: NXP LPC11U14

Notes on the sheet:
VerilogBoy Handheld
Power Supply
System Control
RAM
Audio
LCD
Keypad
MicroSD
USB Slave

Parts:
BAT1: Conn_01x03; BC-15-3P
C1, C2, C3, C9, C10, C11, C12, C14, C15, C17, C18, C23: 10uF; C_0603_1608Metric
C4, C6: 1uF; C_0402_1005Metric
C5: 220nF; C_0402_1005Metric
C7, C19, C21, C22, C102, C105, C106: 4.7uF; C_0603_1608Metric
C8, C20: 100nF; C_0402_1005Metric
C13, C16: 1nF; C_0402_1005Metric
C24, C25, C100, C101, C104: 470nF; C_0402_1005Metric
C103: 47uF; C_0805_2012Metric
D1: LED; D_0603_1608Metric
L1, L2, L3: 4.7uH; L_Vishay_IHLP-1212
L4: 2.2uH; L_Vishay_IHLP-1212
R1, R3: 1K; R_0402_1005Metric
R2: 200K; R_0402_1005Metric
R4: 0.03R; R_0805_2012Metric
R5: 1R; R_0603_1608Metric
R6: 20K; R_0402_1005Metric
R7: 10K; R_0402_1005Metric
U1: AXP209; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm_ThermalVias
U2: SY8008; TSOT-23-5
U100: XC6SLX16-FTG256; Xilinx_FTG256

Connections:
+1V2: C12.2, C13.2, C104.2, C105.2, C106.2, L2.2, U1.10 (DCDC2), U100.G7 (VCCINT), U100.G9 (VCCINT), U100.H8 (VCCINT), U100.H10 (VCCINT), U100.J7 (VCCINT), U100.J9 (VCCINT), U100.K8 (VCCINT), U100.K10 (VCCINT); also elsewhere on the board
+1V8: C25.2, L4.2, R6.2; also elsewhere on the board
+3.3VA: C23.2, U1.11 (LDO4); also elsewhere on the board
+3V3: C15.2, C16.2, C100.1, C101.1, C102.1, C103.1, L3.2, U1.17 (DCDC3), U100.E5 (VCCAUX), U100.F8 (VCCAUX), U100.F11 (VCCAUX), U100.G10 (VCCAUX), U100.H6 (VCCAUX), U100.J10 (VCCAUX), U100.L6 (VCCAUX), U100.L9 (VCCAUX); also elsewhere on the board
+BATT: BAT1.1, C3.1, C9.2, R4.2, U1.38 (BAT), U1.39 (BAT), U1.42 (BATSENSE)
+RAM: C19.2, U1.41 (LDO3); also elsewhere on the board
+RTC: C21.2, U1.28 (LDO1)
/power/TS: BAT1.2, U1.37 (TS)
/power/VINT: C4.1, U1.26 (VINT), U1.27 (LDO1SET)
EXTEN: U1.20 (EXTEN), U2.1 (RUN)
GND: BAT1.3, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C100.2, C101.2, C102.2, C103.2, C104.1, C105.1, C106.1, R1.2, R2.2, R7.1, U1.4 (~OE), U1.9 (PGND2), U1.16 (PGND3), U1.22 (AGND), U1.46 (PGND_CHG), U1.49 (EP), U2.2 (GND), U100.A1 (GND), U100.A16 (GND), U100.B7 (GND), U100.B11 (GND), U100.D4 (GND), U100.D13 (GND), U100.E9 (GND), U100.G2 (GND), U100.G8 (GND), U100.G15 (GND), U100.H7 (GND), U100.H9 (GND), U100.H12 (GND), U100.J5 (GND), U100.J8 (GND), U100.K7 (GND), U100.K9 (GND), U100.L2 (GND), U100.L15 (GND), U100.M8 (GND), U100.N13 (GND), U100.P3 (GND), U100.R6 (GND), U100.R10 (GND), U100.T1 (GND), U100.T16 (GND); also elsewhere on the board
IPSOUT: C2.1, C5.1, C11.2, C14.2, C17.2, C22.2, C24.2, R5.1, U1.7 (VIN2), U1.14 (VIN3), U1.21 (APS), U1.29 (DC3SET), U1.34 (IPSOUT), U1.35 (IPSOUT), U1.40 (LDO3IN), U1.44 (VIN_CHG), U2.4 (VIN)
unnamed: C6.1, U1.24 (VREF)
unnamed: C7.1, U1.19 (GPIO0/LDOIO0)
unnamed: C8.1, R3.1, U1.47 (PWRON)
unnamed: C10.2, L1.2, R4.1, U1.43 (CHSENSE)
unnamed: C18.2, R5.2, U1.13 (LDO24IN)
unnamed: C20.2, U1.12 (LDO2)
unnamed: D1.1 (K), R1.1
unnamed: D1.2 (A), U1.36 (CHGLED)
unnamed: L1.1, U1.45 (LX_CHG)
unnamed: L2.1, U1.8 (LX2)
unnamed: L3.1, U1.15 (LX3)
unnamed: L4.1, U2.3 (SW)
unnamed: R2.1, U1.23 (BIAS)
unnamed: R6.1, R7.2, U2.5 (FB)
PEK: R3.2; also elsewhere on the board
PMU_IRQ: U1.48 (IRQ); also elsewhere on the board
PMU_VBUSEN: U1.6 (~VBUSEN); also elsewhere on the board
PWROK: U1.25 (PWROK); also elsewhere on the board
SYS_SDA: U1.1 (SDA); also elsewhere on the board
VBUS: C1.1, U1.31 (VBUS); also elsewhere on the board

Parts:
ARM_JTAG1: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD
C107, C108, C110, C111, C112, C113, C117, C118, C126: 470nF; C_0402_1005Metric
C109, C114, C119: 4.7uF; C_0603_1608Metric
C115, C116: 18pF; C_0402_1005Metric
D100, D101: 1N5819; D_SOD-123
FPGA_JTAG1: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD
R100, R101, R103, R105, R110, R111, R112, R113, R118: 10K; C_0402_1005Metric
R102: 1K; C_0402_1005Metric
R104: 33R; C_0402_1005Metric
R106, R107, R108: 100K; C_0402_1005Metric
R109: 2.2M; C_0402_1005Metric
R114, R115: 22R; C_0402_1005Metric
R117: 4.7K; C_0402_1005Metric
U100: XC6SLX16-FTG256; Xilinx_FTG256
U101: W25Q32JVZP; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
U102: STM32L052K8Ux; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
U103: PCA9306; VSSOP-8_2.3x2mm_P0.5mm
X100: 24.576MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm
Y100: Crystal; Crystal_SMD_TXC_9HT11-2Pin_2.0x1.2mm_HandSoldering

Connections:
+1V8: U103.2 (VREF1); also elsewhere on the board
+3V3: ARM_JTAG1.1, C107.1, C108.1, C109.1, C110.2, C112.1, C113.1, C114.1, C117.2, C118.2, C119.2, C126.2, FPGA_JTAG1.1, R100.1, R101.1, R103.1, R105.1, R112.1, R113.1, R117.1, R118.1, U100.D2 (VCCO_3), U100.G4 (VCCO_3), U100.J2 (VCCO_3), U100.K4 (VCCO_3), U100.N2 (VCCO_3), U100.N7 (VCCO_2), U100.N10 (VCCO_2), U100.R4 (VCCO_2), U100.R8 (VCCO_2), U102.1 (VDD), U102.5 (VDDA), U102.17 (VDD), U103.7 (VREF2), U103.8 (EN), X100.4 (Vdd); also elsewhere on the board
/syscon/DONE: U100.P13 (DONE_2), U102.15 (PB1)
/syscon/FPGA_CCLK: U100.R11 (IO_L1P_CCLK_2), U101.6 (CLK), U102.30 (PB7)
/syscon/FPGA_CS_N: R106.2, U100.T3 (IO_L65N_CSO_B_2), U101.1 (~CS), U102.32 (PB8)
/syscon/FPGA_MISO: U100.P10 (IO_L3P_D0_DIN_MISO_MISO1_2), U101.2 (DO(IO1)), U102.29 (PB6)
/syscon/FPGA_MOSI: U100.T10 (IO_L3N_MOSI_CSI_B_MISO0_2), U101.5 (DI(IO0)), U102.28 (PB5)
/syscon/FPGA_TCK: FPGA_JTAG1.4, R117.2, U100.C14 (TCK)
/syscon/FPGA_TDI: FPGA_JTAG1.8, U100.C12 (TDI)
/syscon/FPGA_TDO: FPGA_JTAG1.6, U100.E14 (TDO)
/syscon/FPGA_TMS: FPGA_JTAG1.2, U100.A15 (TMS)
/syscon/GCLK: R104.1, X100.3 (OUT)
/syscon/PROGRAM_B: R100.2, U100.T2 (PROGRAM_B_2), U102.16 (PB2)
/syscon/SWCLK: ARM_JTAG1.4, U102.24 (PA14)
/syscon/SWDIO: ARM_JTAG1.2, R118.2, U102.23 (PA13)
ENC_A: U102.18 (PA8); also elsewhere on the board
ENC_B: U102.13 (PA7); also elsewhere on the board
GND: ARM_JTAG1.3, ARM_JTAG1.5, C107.2, C108.2, C109.2, C110.1, C111.1, C112.2, C113.2, C114.2, C115.1, C116.1, C117.1, C118.1, C119.1, C126.1, FPGA_JTAG1.3, FPGA_JTAG1.5, R102.1, R109.2, R110.1, R111.1, U100.P14 (SUSPEND), U101.4 (GND), U101.9 (EP), U102.33 (VSS), U103.1 (GND), X100.2 (GND); also elsewhere on the board
LCD_RESET: U102.11 (PA5); also elsewhere on the board
unnamed: ARM_JTAG1.10, D100.1 (K)
unnamed: C111.2, R106.1, R107.1, R108.1, U101.8 (VCC)
unnamed: C115.2, U102.2 (PC14), Y100.1
unnamed: C116.2, R109.1, U102.3 (PC15), Y100.2
unnamed: D100.2 (A), D101.2 (A), U102.4 (NRST)
unnamed: R101.2, U100.T11 (IO_L1N_M0_CMPMISO_2)
unnamed: R102.2, U100.N11 (IO_L13P_M1_2)
unnamed: R103.2, U100.R3 (IO_L65P_INIT_B_2)
unnamed: R104.2, U100.N8 (IO_L29N_GCLK2_2)
unnamed: R105.2, X100.1 (EN)
unnamed: R107.2, U101.3 (IO2)
unnamed: R108.2, U101.7 (IO3)
unnamed: R110.2, U102.31 (BOOT0)
unnamed: R111.2, U102.26 (PB3)
unnamed: R112.2, U102.8 (PA2), U103.6 (SCL2)
unnamed: R113.2, U102.9 (PA3), U103.5 (SDA2)
unnamed: R114.1, U102.21 (PA11)
unnamed: R115.1, U102.22 (PA12)
P10: U100.P8 (IO_L30P_GCLK1_D13_2); also elsewhere on the board
P11: U100.T9 (IO_L23N_2); also elsewhere on the board
P12: U100.R9 (IO_L23P_2); also elsewhere on the board
P13: U100.P9 (IO_L14N_D12_2); also elsewhere on the board
P14: U100.P11 (IO_L13N_D10_2); also elsewhere on the board
P15: U100.P12 (IO_L12N_D2_MISO3_2); also elsewhere on the board
PMU_IRQ: U102.6 (PA0); also elsewhere on the board
PMU_VBUSEN: U102.7 (PA1); also elsewhere on the board
PWROK: D101.1 (K), U100.N5 (IO_L49P_D3_2); also elsewhere on the board
SYS_SCL: U103.3 (SCL1); also elsewhere on the board
SYS_SDA: U103.4 (SDA1); also elsewhere on the board
USB_DM: R114.2; also elsewhere on the board
USB_DP: R115.2; also elsewhere on the board

Notes on the sheet:
Avoid using bank 3 for LX9 compatibility 为兼容LX9避免使用Bank 3

Parts:
C120, C121, C123, C124, C200, C201: 470nF; C_0402_1005Metric
C122, C125: 4.7uF; C_0603_1608Metric
R116: 2.2K; C_0402_1005Metric
R200: 10K; R_0402_1005Metric
U100: XC6SLX16-FTG256; Xilinx_FTG256
U200: IS66WVE4M16; BGA-48_6x8_6.0x8.0mm

Connections:
+1V8: C120.1, C121.1, C122.1, C123.2, C124.2, C125.2, U100.B4 (VCCO_0), U100.B9 (VCCO_0), U100.B13 (VCCO_0), U100.D7 (VCCO_0), U100.D10 (VCCO_0), U100.D15 (VCCO_1), U100.G13 (VCCO_1), U100.J15 (VCCO_1), U100.K13 (VCCO_1), U100.N15 (VCCO_1), U100.R13 (VCCO_1); also elsewhere on the board
+RAM: C200.1, C201.1, R200.1, U200.D6 (VDD), U200.E1 (VDDQ); also elsewhere on the board
/ram/RAM_A0: U100.F15 (IO_L35P_A11_M1A7_1), U200.A3 (A0)
/ram/RAM_A1: U100.F16 (IO_L35N_A10_M1A2_1), U200.A4 (A1)
/ram/RAM_A2: U100.E15 (IO_L34P_A13_M1WE_1), U200.A5 (A2)
/ram/RAM_A3: U100.H16 (IO_L37N_A6_M1A1_1), U200.B3 (A3)
/ram/RAM_A4: U100.G16 (IO_L36N_A8_M1BA1_1), U200.B4 (A4)
/ram/RAM_A5: U100.F13 (IO_L32P_A17_M1A8_1), U200.C3 (A5)
/ram/RAM_A6: U100.F14 (IO_L32N_A16_M1A9_1), U200.C4 (A6)
/ram/RAM_A7: U100.H14 (IO_L39N_M1ODT_1), U200.D4 (A7)
/ram/RAM_A8: U100.R12 (IO_L52P_M1DQ14_1), U200.H2 (A8)
/ram/RAM_A9: U100.M14 (IO_L74N_DOUT_BUSY_1), U200.H3 (A9)
/ram/RAM_A10: U100.M13 (IO_L74P_AWAKE_1), U200.H4 (A10)
/ram/RAM_A11: U100.T15 (IO_L50N_M1UDQSN_1), U200.H5 (A11)
/ram/RAM_A12: U100.L13 (IO_L53N_VREF_1), U200.G3 (A12)
/ram/RAM_A13: U100.L14 (IO_L47P_FWE_B_M1DQ0_1), U200.G4 (A13)
/ram/RAM_A14: U100.K14 (IO_L41N_GCLK8_M1CASN_1), U200.F3 (A14)
/ram/RAM_A15: U100.J14 (IO_L43P_GCLK5_M1DQ4_1), U200.F4 (A15)
/ram/RAM_A16: U100.H13 (IO_L39P_M1A3_1), U200.E4 (A16)
/ram/RAM_A17: U100.G14 (IO_L36P_A9_M1BA0_1), U200.D3 (A17)
/ram/RAM_A18: U100.R15 (IO_L49P_M1DQ10_1), U200.H1 (A18)
/ram/RAM_A19: U100.R16 (IO_L49N_M1DQ11_1), U200.G2 (A19)
/ram/RAM_A20: U100.T13 (IO_L51N_M1DQ13_1), U200.H6 (A20)
/ram/RAM_A21: U100.J13 (IO_L41P_GCLK9_IRDY1_M1RASN_1), U200.E3 (A21)
/ram/RAM_CE_N: R200.2, U100.D14 (IO_L31P_A19_M1CKE_1), U200.B5 (~CE)
/ram/RAM_DQ0: U100.E16 (IO_L34N_A12_M1BA2_1), U200.B6 (DQ0)
/ram/RAM_DQ1: U100.C15 (IO_L33P_A15_M1A10_1), U200.C5 (DQ1)
/ram/RAM_DQ2: U100.C16 (IO_L33N_A14_M1A4_1), U200.C6 (DQ2)
/ram/RAM_DQ3: U100.B16 (IO_L29N_A22_M1A14_1), U200.D5 (DQ3)
/ram/RAM_DQ4: U100.T12 (IO_L52N_M1DQ15_1), U200.E5 (DQ4)
/ram/RAM_DQ5: U100.E13 (IO_L1P_A25_1), U200.F5 (DQ5)
/ram/RAM_DQ6: U100.B15 (IO_L29P_A23_M1A13_1), U200.F6 (DQ6)
/ram/RAM_DQ7: U100.T14 (IO_L51P_M1DQ12_1), U200.G6 (DQ7)
/ram/RAM_DQ8: U100.K15 (IO_L44P_A3_M1DQ6_1), U200.B1 (DQ8)
/ram/RAM_DQ9: U100.M16 (IO_L46N_FOE_B_M1DQ3_1), U200.C1 (DQ9)
/ram/RAM_DQ10: U100.L16 (IO_L47N_LDC_M1DQ1_1), U200.C2 (DQ10)
/ram/RAM_DQ11: U100.M15 (IO_L46P_FCS_B_M1DQ2_1), U200.D2 (DQ11)
/ram/RAM_DQ12: U100.N16 (IO_L45N_A0_M1LDQSN_1), U200.E2 (DQ12)
/ram/RAM_DQ13: U100.P16 (IO_L48N_M1DQ9_1), U200.F2 (DQ13)
/ram/RAM_DQ14: U100.N14 (IO_L45P_A1_M1LDQS_1), U200.F1 (DQ14)
/ram/RAM_DQ15: U100.P15 (IO_L48P_HDC_M1DQ8_1), U200.G1 (DQ15)
/ram/RAM_LB_N: U100.J16 (IO_L43N_GCLK4_M1DQ5_1), U200.A1 (~LB)
/ram/RAM_OE_N: U100.H15 (IO_L37P_A7_M1A0_1), U200.A2 (~OE)
/ram/RAM_UB_N: U100.K16 (IO_L44N_A2_M1DQ7_1), U200.B2 (~UB)
/ram/RAM_WE_N: U100.R14 (IO_L50P_M1UDQS_1), U200.G5 (~WE)
/ram/RAM_ZZ_N: U100.D16 (IO_L31N_A18_M1A12_1), U200.A6 (~ZZ)
GND: C120.2, C121.2, C122.2, C123.1, C124.1, C125.1, C200.2, C201.2, R116.1, U200.D1 (VSSQ), U200.E6 (VSS); also elsewhere on the board
LCD_CLK: U100.C11 (IO_L39P_0); also elsewhere on the board
LCD_D0: U100.C13 (IO_L63P_SCP7_0); also elsewhere on the board
LCD_D1: U100.B14 (IO_L65P_SCP3_0); also elsewhere on the board
LCD_D2: U100.A12 (IO_L62N_VREF_0); also elsewhere on the board
LCD_D4: U100.A11 (IO_L39N_0); also elsewhere on the board
LCD_D5: U100.B12 (IO_L62P_0); also elsewhere on the board
LCD_D6: U100.C10 (IO_L37N_GCLK12_0); also elsewhere on the board
LCD_D7: U100.A10 (IO_L35N_GCLK16_0); also elsewhere on the board
LCD_D8: U100.B10 (IO_L35P_GCLK17_0); also elsewhere on the board
LCD_D9: U100.A9 (IO_L34N_GCLK18_0); also elsewhere on the board
LCD_D10: U100.F9 (IO_L40P_0); also elsewhere on the board
LCD_D11: U100.A8 (IO_L33N_0); also elsewhere on the board
LCD_D12: U100.B8 (IO_L33P_0); also elsewhere on the board
LCD_D13: U100.A7 (IO_L6N_0); also elsewhere on the board
LCD_D14: U100.B6 (IO_L4P_0); also elsewhere on the board
LCD_D15: U100.A6 (IO_L4N_0); also elsewhere on the board
LCD_D16: U100.B5 (IO_L2P_0); also elsewhere on the board
LCD_D17: U100.A5 (IO_L2N_0); also elsewhere on the board
LCD_DE: U100.D11 (IO_L66P_SCP1_0); also elsewhere on the board
LCD_PCLK: U100.D9 (IO_L40N_0); also elsewhere on the board
LCD_TE: U100.A14 (IO_L65N_SCP2_0); also elsewhere on the board
LCD_VS: U100.E11 (IO_L64N_SCP4_0); also elsewhere on the board
unnamed: R116.2, U100.C4 (IO_L1P_HSWAPEN_0)
SD_CLK: U100.D6 (IO_L7P_0); also elsewhere on the board
SD_CMD: U100.C6 (IO_L7N_0); also elsewhere on the board
SD_D0: U100.C5 (IO_L3N_0); also elsewhere on the board
SD_D1: U100.D5 (IO_L3P_0); also elsewhere on the board
SD_D2: U100.D8 (IO_L38P_0); also elsewhere on the board
SD_D3: U100.C7 (IO_L6P_0); also elsewhere on the board

Parts:
C300, C301, C302, C303, C304: 470nF; C_0402_1005Metric
C305, C306: 4.7uF; C_0603_1608Metric
C307, C308: 100uF; C_1206_3216Metric
C309, C310: 100nF; C_0402_1005Metric
D300, D301, D302: ESD5B5.0ST1G; D_SOD-523
J300: Conn_01x02; PinHeader_1x02_P2.00mm_Vertical
J301: AudioJack3_Ground_SwitchTR; PJ-327E
L300, L301: BLM18BD252SN1; L_0603_1608Metric
R300, R301: 22R; R_0402_1005Metric
R302: 47K; R_0402_1005Metric
RN300: 22; R_Array_Convex_4x0402
U300: WM8960; QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm

Connections:
+1V8: C300.1, C301.1, U300.8 (DCVDD), U300.10 (DBVDD); also elsewhere on the board
+3.3VA: C304.1, C305.1, R302.1, U300.32 (AVDD); also elsewhere on the board
+3V3: C302.1, C303.1, C306.1, U300.21 (SPKVDD), U300.26 (SPKVDD); also elsewhere on the board
GND: C300.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C309.1, C310.1, D300.2 (A2), D301.2 (A2), D302.2 (A2), J301.G, U300.9 (DGND), U300.20 (SPKGND), U300.24 (SPKGND), U300.28 (AGND), U300.33 (GND_PADDLE); also elsewhere on the board
unnamed: C307.1, U300.31 (HP_L)
unnamed: C307.2, C309.2, L300.1
unnamed: C308.1, U300.29 (HP_R)
unnamed: C308.2, C310.2, L301.1
unnamed: D300.1 (A1), J301.T, L300.2
unnamed: D301.1 (A1), J301.R, L301.2
unnamed: D302.1 (A1), J301.S, R302.2, U300.7 (RINPUT3)
unnamed: J300.1, U300.22 (SPK_RP)
unnamed: J300.2, U300.19 (SPK_RN)
unnamed: R300.1, U300.17 (SCLK)
unnamed: R301.1, U300.18 (SDIN)
unnamed: RN300.5 (R4.2), U300.11 (MCLK)
unnamed: RN300.6 (R3.2), U300.14 (DACDAT)
unnamed: RN300.7 (R2.2), U300.12 (BCLK)
unnamed: RN300.8 (R1.2), U300.13 (DACLRC)

Notices in the files:
README.md:
License:
The dsicore is made by twlostow, released under LGPL 3.0.
The PicoRV32 is free and open hardware licensed under the [ISC license](http://en.wikipedia.org/wiki/ISC_license)
(a license that is similar in terms to the MIT license or the 2-clause BSD license).
Some firmware code of pano-g1 target are released to public domain.
All other software codes (including simulation code) are licensed under MIT.
All other HDL codes are licensed under OHDL 1.0.
All other text documents are licensed under CC BY-SA 4.0
